# Keil uVision project STM32_Project_Template.uvproj, settings and files
target STM32F103VET6 (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: weina +hex
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,USE_STM3210E_EVAL
  c include: ..\lib\inc;..\lib\src;..\sys;..\user\driver\inc;..\user\driver\src;..\user\function\inc;..\user\driver\src;..\user\resoucre;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group sys
    ../sys/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group lib
    ../lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group dirver
    ../user/driver/src/: flash.c fsmc_sram.c lcd_12864.c system_init.c usart.c
  group user
    ../user/: main.c stm32f10x_it.c
    ../user/function/src/: TimerTask.c Menu.c
  group res
    ../user/resoucre/: pic.c GB1616.h GB2432.h
  group doc
    ../doc/: readme.txt
